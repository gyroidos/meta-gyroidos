include linux-gyroidos.inc

LINUX_VERSION_EXTENSION = "-gyroidos"
