SRC_URI += "file://trustx.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

