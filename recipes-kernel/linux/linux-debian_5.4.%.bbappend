linux-vanilla_5.4.%.bbappend