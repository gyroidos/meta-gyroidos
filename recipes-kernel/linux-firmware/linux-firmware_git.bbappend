PACKAGES =+ "linux-firmware-all "

LICENSE_${PN}-ralink = "Firmware-bundle-package"
