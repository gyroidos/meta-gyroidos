FILESEXTRAPATHS:prepend:cml-base := "${THISDIR}/${PN}:"
