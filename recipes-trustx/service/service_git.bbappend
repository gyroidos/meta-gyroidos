/home/wruck/yocto/ws-githubfork/out-yocto/cmld_git.bbappend