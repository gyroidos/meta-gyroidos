FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"
SRC_URI:append = "file://0001-Add-support-for-RSA-public-key-encoded-with-id-RSASS.patch"
