FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Prevent-accessing-of-global-c-objects-once-they-are-.patch"
