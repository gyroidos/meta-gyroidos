require trustx-core.bb

IMAGE_INSTALL += "\
	screen \
	trusted-connector \
"
